Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: aedbef35-90e2-44c2-998b-5c4f75c56fda, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-10T23:56:00+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12803500_ROK_KWTUS7054F_OBSW:39705410_ROK_12803500_KWTUS7054F_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_CLST, Spruce, z_Miele_Design_OBSW, <Unnamed>, z_Miele_Design_Glass Black, z_Miele_Design_Cast, z_Miele_Connection_Connection_Modul, z_Miele_Design_Glass
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 597 mm; Height: 819 mm; Depth: 579 mm
Pset_BuildingElementProxyCommon - Reference: 39705410_ROK_12803500_KWTUS7054F_OBSW; sets with these values: 2
